# Keil uVision project STM32F103ZET6_TESTCODE.uvprojx, settings and files
target STM32F103ZET6_TESTCODE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F103ZET6_TESTCODE +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output .\Build\STM32F103ZET6_TESTCODE.bin .\Build\STM32F103ZET6_TESTCODE.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/01-Task;../Core/06-Unitity;..\Middlewares\Third_Party\FreeModbusMaster\modbus\include;..\Middlewares\Third_Party\FreeModbusMaster\modbus\rtu;..\Middlewares\Third_Party\FreeModbusMaster\port
  asm include: ..\Core\Inc;..\Core\01-Task;..\Core\06-Unitity
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c iwdg.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group 01-Task
    ../Core/01-Task/: Task_Mem.c Task_Ymodem.c
  group 10-Middlewares/FreeModbusMaster
    ../Middlewares/Third_Party/FreeModbusMaster/modbus/: mb_m.c
    ../Middlewares/Third_Party/FreeModbusMaster/modbus/rtu/: mbrtu_m.c mbcrc.c
    ../Middlewares/Third_Party/FreeModbusMaster/modbus/functions/: mbfuncholding_m.c mbfunccoils_m.c mbfuncdisc_m.c mbfuncinput_m.c mbfuncother.c mbutils.c
    ../Middlewares/Third_Party/FreeModbusMaster/port/rtt/: portevent_m.c portserial_m.c porttimer_m.c port.c
    ../Middlewares/Third_Party/FreeModbusMaster/port/: user_mb_app_m.c
software components: CMSIS:CORE 4.3.0
